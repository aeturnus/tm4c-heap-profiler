# Keil uVision project HeapProfiler.uvproj, settings and files
target HeapProfiler (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: HeapProfiler
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT CHIP_NAME="TM4C1294"
  c misc: --C99
  c include: ..;..\..\..;.\inc;.\external\allocators\inc;.\external\libbtn\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ./src/: heap.c main.c malloc.c SysTick.c UART.c startup.s Random.c shell.c command.c
  group Allocators
    ./external/allocators/src/: knuth.c
  group libbtn
    ./external/libbtn/src/: bst.c container.c cstr.c tokenizer.c vector.c
  group Commands
    ./src/commands/: set_impl.c benchmark.c
  group Benchmarks
    ./src/commands/benchmarks/: bench_random.c
